# Keil uVision project pilot.uvprojx, settings and files
target STM32F103 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pilot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD.USE_STDPERIPH_DRIVER
  c include: ..\STLib\core\startup;..\STLib\core;..\STLib\fwlib\inc;..\user;..\boards\stm32f103c8t6;..\drivers\led;..\utils
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../STLib/core/: core_cm3.c system_stm32f10x.c
    ../STLib/core/startup/: startup_stm32f10x_md.s
  group fwlib
    ../STLib/fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group boards
    ../boards/stm32f103c8t6/: board_config.c
  group drivers
    ../drivers/led/: led.c
  group user
    ../user/: main.c stm32f10x_it.c stm32f10x_conf.h
  group utils
    ../utils/: system_config.h
  group Doc
    ../Doc/: read.txt
